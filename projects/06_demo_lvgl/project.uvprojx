# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\Board_Drivers;libraries\Board_Drivers\lcd;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\LVGL-v8.3.5\src;packages\LVGL-v8.3.5\src\core;packages\LVGL-v8.3.5\src\draw;packages\LVGL-v8.3.5\src\extra;packages\LVGL-v8.3.5\src\font;packages\LVGL-v8.3.5\src\hal;packages\LVGL-v8.3.5\src\misc;packages\LVGL-v8.3.5\src\widgets;packages\LVGL-v8.3.5\src\draw\arm2d;packages\LVGL-v8.3.5\src\draw\sdl;packages\LVGL-v8.3.5\src\draw\stm32_dma2d;packages\LVGL-v8.3.5\src\draw\sw;packages\LVGL-v8.3.5\src\draw\swm341_dma2d;packages\LVGL-v8.3.5\src\draw\nxp\pxp;packages\LVGL-v8.3.5\src\draw\nxp\vglite;packages\LVGL-v8.3.5\src\extra\layouts;packages\LVGL-v8.3.5\src\extra\libs;packages\LVGL-v8.3.5\src\extra\others;packages\LVGL-v8.3.5\src\extra\themes;packages\LVGL-v8.3.5\src\extra\widgets;packages\LVGL-v8.3.5\src\extra\layouts\flex;packages\LVGL-v8.3.5\src\extra\layouts\grid;packages\LVGL-v8.3.5\src\extra\libs\bmp;packages\LVGL-v8.3.5\src\extra\libs\ffmpeg;packages\LVGL-v8.3.5\src\extra\libs\freetype;packages\LVGL-v8.3.5\src\extra\libs\fsdrv;packages\LVGL-v8.3.5\src\extra\libs\gif;packages\LVGL-v8.3.5\src\extra\libs\png;packages\LVGL-v8.3.5\src\extra\libs\qrcode;packages\LVGL-v8.3.5\src\extra\libs\rlottie;packages\LVGL-v8.3.5\src\extra\libs\sjpg;packages\LVGL-v8.3.5\src\extra\others\fragment;packages\LVGL-v8.3.5\src\extra\others\gridnav;packages\LVGL-v8.3.5\src\extra\others\ime;packages\LVGL-v8.3.5\src\extra\others\imgfont;packages\LVGL-v8.3.5\src\extra\others\monkey;packages\LVGL-v8.3.5\src\extra\others\msg;packages\LVGL-v8.3.5\src\extra\others\snapshot;packages\LVGL-v8.3.5\src\extra\themes\basic;packages\LVGL-v8.3.5\src\extra\themes\default;packages\LVGL-v8.3.5\src\extra\themes\mono;packages\LVGL-v8.3.5\src\extra\widgets\animimg;packages\LVGL-v8.3.5\src\extra\widgets\calendar;packages\LVGL-v8.3.5\src\extra\widgets\chart;packages\LVGL-v8.3.5\src\extra\widgets\colorwheel;packages\LVGL-v8.3.5\src\extra\widgets\imgbtn;packages\LVGL-v8.3.5\src\extra\widgets\keyboard;packages\LVGL-v8.3.5\src\extra\widgets\led;packages\LVGL-v8.3.5\src\extra\widgets\list;packages\LVGL-v8.3.5\src\extra\widgets\menu;packages\LVGL-v8.3.5\src\extra\widgets\meter;packages\LVGL-v8.3.5\src\extra\widgets\msgbox;packages\LVGL-v8.3.5\src\extra\widgets\span;packages\LVGL-v8.3.5\src\extra\widgets\spinbox;packages\LVGL-v8.3.5\src\extra\widgets\spinner;packages\LVGL-v8.3.5\src\extra\widgets\tabview;packages\LVGL-v8.3.5\src\extra\widgets\tileview;packages\LVGL-v8.3.5\src\extra\widgets\win;packages\LVGL-v8.3.5\demos;packages\LVGL-v8.3.5\demos\benchmark;packages\LVGL-v8.3.5\demos\keypad_encoder;packages\LVGL-v8.3.5\demos\music;packages\LVGL-v8.3.5\demos\stress;packages\LVGL-v8.3.5\demos\widgets;packages\LVGL-v8.3.5\demos\music\assets;applications\lvgl\demo;applications\lvgl;packages\LVGL-v8.3.5\env_support\rt-thread;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    rt-thread/components/libc/cplusplus/: cxx_Thread.cpp cxx_Mutex.cpp cxx_crt.cpp cxx_crt_init.c cxx_Semaphore.cpp
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/Board_Drivers/lcd/: drv_lcd.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_pwm.c drv_soft_spi.c drv_spi.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_line.c lv_draw_sdl_stack_blur.c lv_draw_sdl_layer.c lv_draw_sdl_mask.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl_polygon.c lv_draw_sdl.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_rect.c
    packages/LVGL-v8.3.5/src/misc/: lv_color.c lv_templ.c lv_anim.c lv_fs.c lv_style.c lv_utils.c lv_txt.c lv_async.c lv_printf.c lv_ll.c lv_style_gen.c lv_log.c lv_tlsf.c lv_lru.c lv_txt_ap.c lv_timer.c lv_anim_timeline.c lv_bidi.c lv_math.c lv_area.c lv_gc.c lv_mem.c
    packages/LVGL-v8.3.5/src/core/: lv_obj_scroll.c lv_obj_style_gen.c lv_refr.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_indev.c lv_event.c lv_obj_pos.c lv_group.c lv_obj_tree.c lv_obj_style.c lv_theme.c lv_disp.c
    packages/LVGL-v8.3.5/src/font/: lv_font_montserrat_28.c lv_font_montserrat_24.c lv_font_montserrat_36.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_28_compressed.c lv_font.c lv_font_unscii_16.c lv_font_montserrat_40.c lv_font_unscii_8.c lv_font_montserrat_10.c lv_font_montserrat_18.c lv_font_fmt_txt.c lv_font_montserrat_26.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_32.c lv_font_montserrat_14.c lv_font_montserrat_48.c lv_font_montserrat_16.c lv_font_montserrat_12.c lv_font_montserrat_30.c lv_font_montserrat_22.c lv_font_montserrat_34.c lv_font_simsun_16_cjk.c lv_font_montserrat_38.c lv_font_montserrat_12_subpx.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_46.c lv_font_montserrat_20.c
    packages/LVGL-v8.3.5/demos/benchmark/assets/: lv_font_bechmark_montserrat_16_compr_az.c.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_chroma_keyed.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_alpha16.c lv_font_bechmark_montserrat_12_compr_az.c.c img_benchmark_cogwheel_indexed16.c
    packages/LVGL-v8.3.5/demos/music/assets/: img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_list_border.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_slider_knob.c img_lv_demo_music_list_border_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_logo.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_cover_2.c img_lv_demo_music_btn_loop_large.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/widgets/: lv_img.c lv_switch.c lv_line.c lv_bar.c lv_btnmatrix.c lv_arc.c lv_btn.c lv_slider.c lv_checkbox.c lv_table.c lv_canvas.c lv_label.c lv_objx_templ.c lv_roller.c lv_textarea.c lv_dropdown.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/draw/: lv_draw_label.c lv_draw_layer.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_draw.c lv_draw_img.c lv_draw_line.c lv_img_cache.c lv_img_decoder.c lv_draw_arc.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_win32.c lv_fs_posix.c lv_fs_fatfs.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw_polygon.c lv_draw_sw_gradient.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_transform.c lv_draw_sw_rect.c lv_draw_sw_dither.c lv_draw_sw.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_line.c lv_draw_sw_letter.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.5/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite_line.c lv_draw_vglite.c lv_vglite_buf.c lv_draw_vglite_arc.c lv_vglite_utils.c lv_draw_vglite_rect.c lv_draw_vglite_blend.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.5/demos/widgets/assets/: img_lvgl_logo.c img_demo_widgets_avatar.c img_clothes.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/demos/music/: lv_demo_music.c lv_demo_music_main.c lv_demo_music_list.c
    packages/LVGL-v8.3.5/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
  group LVGL-demo
    applications/lvgl/demo/: lv_demo.c lv_demo_calendar.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
